# Repository MrFlowProduction/Lola

File README.md:

# Lola
Lola Node PCB Desing for Indigo network

## EAGLE design lola.brd

Parts:
C1, C2, C3, C4, C8, C11, C24: 0.1uF; C0603
C5, C6: 22pF; C0603
C23: 1uF; C0603
D8: 1655; LED_1655
LED5: LEDCHIPLED_0805; CHIPLED_0805
R1, R5, R6, R15: 10K; R0603
R2: 1M; R0603
S1, S2: MOMENTARY-SWITCH-SPST-SMD-4.6X2.8MM; TACTILE_SWITCH_SMD_4.6X2.8MM
T1, T2: MUN2211T1-NPN_DRIVER-SC59-BEC; SC59-BEC
U1: ATMEGA328P_TQFP; TQFP32-08
U3: AT24C256C-SSHL-T; SOIC127P600X175-8N
U5: DS1338Z-33+T&R; SOIC127P600X175-8N
U$8: BUZZER_5X9.6
Y1: 8MHz; CRYSTAL-SMD-5X3.2-4PAD
Y2: 32.768kHz; CRYSTAL-SMD-3.2X1.5MM

Connections:
3.3V: C1.1, C2.1, C3.1, C4.1, C11.1, C23.1, C24.2, D8.3 (VDD), R1.1, R5.2, R6.2, R15.2, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U1.20 (AREF), U3.8 (VCC), U5.8 (VCC), U$8.+ (VCC); also elsewhere on the board
!EXT_RESET: C8.2; also elsewhere on the board
!RESET: C8.1, R1.2, S1.1, S1.2 (1), U1.29 (PC6(/RESET)); also elsewhere on the board
ADC_RDY: U1.9 (PD5(T1)); also elsewhere on the board
BATT_SENSE: U1.26 (PC3(ADC3)); also elsewhere on the board
BUCK_EN: U1.23 (PC0(ADC0)); also elsewhere on the board
BUZZER: T1.B, U1.12 (PB0(ICP))
CHG: U1.25 (PC2(ADC2)); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C11.2, C23.2, C24.1, D8.1 (VSS), S1.3 (2), S1.4 (2), S2.3 (2), S2.4 (2), T1.E, T2.E, U1.3 (GND), U1.5 (GND), U1.21 (AGND), U3.1 (A0), U3.2 (A1), U3.3 (A2), U3.4 (GND), U3.7 (WP), U5.4 (GND), Y1.2 (3), Y1.4 (3); also elsewhere on the board
LED: T2.B, U1.13 (PB1(OC1A))
MISO: U1.16 (PB4(MISO)); also elsewhere on the board
MOSI: U1.15 (PB3(MOSI/OC2)); also elsewhere on the board
unnamed: LED5.A, R15.1
unnamed: U5.1 (X1), Y2.P$2 (2)
unnamed: U5.2 (X2), Y2.P$1 (1)
unnamed: LED5.C, T2.C
unnamed: T1.C, U$8.- (GND)
unnamed: C5.1, R2.2, U1.7 (PB6(XTAL1/TOSC1)), Y1.3 (1)
unnamed: C6.1, R2.1, U1.8 (PB7(XTAL2/TOSC2)), Y1.1 (2)
NEO_LED: D8.2 (DIN), U1.2 (PD4(XCK/T0))
OUT_EN: U1.24 (PC1(ADC1)); also elsewhere on the board
RF_INT: U1.1 (PD3(INT1)); also elsewhere on the board
RF_SS: U1.10 (PD6(AIN0)); also elsewhere on the board
RX: U1.30 (PD0(RXD)); also elsewhere on the board
SCK: U1.17 (PB5(SCK)); also elsewhere on the board
SCL: R5.1, U1.28 (PC5(ADC5/SCL)), U3.6 (SCL), U5.6 (SCL); also elsewhere on the board
SDA: R6.1, U1.27 (PC4(ADC4/SDA)), U3.5 (SDA), U5.5 (SDA); also elsewhere on the board
SDI: U1.32 (PD2(INT0)); also elsewhere on the board
SW: S2.1, S2.2 (1), U1.14 (PB2(SS/OC1B))
TX: U1.31 (PD1(TXD)); also elsewhere on the board
VBAT: U5.3 (VBAT)

Parts:
C7: 0.1uF; C0603
CN1: USBMINIB; USB-MINIB
D1, D2: transil; SOD-323
F1: 6V/0.5A; 1206
IC1: FT232RL; SSOP28
LED1, LED2: LEDCHIPLED_0805; CHIPLED_0805
R3, R4: 1K; R0603

Connections:
5V: F1.2, IC1.20 (VCC); also elsewhere on the board
!EXT_RESET: IC1.3 (!RTS); also elsewhere on the board
FT_3.3V: C7.1, IC1.4 (VCCIO), IC1.17 (3V3OUT), R3.2, R4.2
GND: C7.2, CN1.GND, D1.A, D2.A, IC1.7 (GND), IC1.18 (GND), IC1.21 (GND), IC1.25 (GND); also elsewhere on the board
unnamed: CN1.VBUS, F1.1
unnamed: CN1.D+, D2.C, IC1.15 (USBDP)
unnamed: CN1.D-, D1.C, IC1.16 (USBDM)
unnamed: LED2.A, R4.1
unnamed: IC1.22 (CBUS1), LED2.C
unnamed: IC1.23 (CBUS0), LED1.C
unnamed: LED1.A, R3.1
RX: IC1.1 (TXD); also elsewhere on the board
TX: IC1.5 (RXD); also elsewhere on the board

Parts:
C9, C14, C25, C26: 0.1uF; C0603
C10: 4.7uF; C0603
C15, C16, C17, C18: 10uF; C0603
D4, D5, D6, D7, D9: transil; SOD-323
J1: CONN_04LOCK_LONGPADS; 1X04_LOCK_LONGPADS
J3: CONN_06NO_SILK_FEMALE_PTH; 1X06_NO_SILK
J4: CONN_025MM; SCREWTERMINAL-5MM-2
J7: CONN_063.5MM-6; SCREWTERMINAL-3.5MM-6
JP1, JP2, JP3: JUMPER-SMT_2_NO_NO-SILK; SMT-JUMPER_2_NO_NO-SILK
L2, L3, L4, L5: ferrit; 0603
LED3, LED4: LEDCHIPLED_0805; CHIPLED_0805
Q2: DMG1013UWQ-7; SOT23-3
R10: 10K; R0603
R13, R14: 2K; R0603
U2: RFM69HW; RFM69W-XXXS2
U4: ADS1115IDGST; SOP50P490X110-10N
U6: SHT21; SON100P300X300X110-7N
U$4: OLED_0.96_I2C
X1: SMACONNECTOR_EDGE_UFL; SMA_EDGELAUNCH_UFL

Connections:
3.3V: C9.1, C10.1, C14.1, C25.1, C26.2, J1.2, J3.1, Q2.2 (S), R10.2, U2.8 (3.3V), U4.8 (VDD), U6.5 (VDD), U$4.VCC; also elsewhere on the board
5V_OUT: J7.6, R14.1; also elsewhere on the board
!RESET: J3.3; also elsewhere on the board
A0: D4.C, J7.4, L2.1
A1: D5.C, J7.3, L3.1
A2: D6.C, J7.2, L4.1
A3: D7.C, J7.1, L5.1
ADC_RDY: U4.2 (ALERT/RDY); also elsewhere on the board
AIN0: C15.2, L2.2, U4.4 (AIN0)
AIN1: C16.2, L3.2, U4.5 (AIN1)
AIN2: C17.2, L4.2, U4.6 (AIN2)
AIN3: C18.2, L5.2, U4.7 (AIN3)
EXP: U6.7 (EXP)
GND: C9.2, C10.2, C14.2, C15.1, C16.1, C17.1, C18.1, C25.2, C26.1, D4.A, D5.A, D6.A, D7.A, D9.A, J1.1, J3.2, J4.2, LED3.C, LED4.C, U2.9 (GND), U2.11 (GND), U4.1 (ADDR), U4.3 (GND), U6.2 (VSS), U$4.GND, X1.GND@1 (GND1), X1.GND@2 (GND2), X1.GND@3 (GND3), X1.GND@4 (GND4); also elsewhere on the board
MISO: J3.5, JP1.2; also elsewhere on the board
MOSI: J3.6, JP2.2; also elsewhere on the board
unnamed: U2.10 (ANT), X1.P (ANT)
unnamed: LED3.A, R14.2
unnamed: LED4.A, R13.2
OUT_EN: Q2.1 (G), R10.1; also elsewhere on the board
PW_OUT: J4.1, Q2.3 (D), R13.1
RF_INT: U2.2 (DIO0); also elsewhere on the board
RF_SS: U2.15 (NSS); also elsewhere on the board
RMISO: JP1.1, U2.13 (MISO)
RMOSI: JP2.1, U2.14 (MOSI)
RSCK: JP3.1, U2.12 (SCK)
SCK: J3.4, JP3.2; also elsewhere on the board
SCL: J1.4, U4.10 (SCL), U6.6 (SCL), U$4.SCL; also elsewhere on the board
SDA: J1.3, U4.9 (SDA), U6.1 (SDA), U$4.SDA; also elsewhere on the board
SDI: D9.C, J7.5; also elsewhere on the board

Parts:
C12: 4.7uF; C0603
C13: 4.7uF; C1206
C19, C20, C21: 10uF; C1206
C22: 1uF; C0805
C27: 100uF; CT6032
D3: DIODE-SCHOTTKY-B340A; SMA-DIODE
F2: PTCFUSE-1812; 1812
F3: 6V/0.5A; 1206
IC2: MCP73833-UN; MSOP10
L1: LQH32PN4R7NN0L; L1812
Q1: MOSFET_PCH-DMG2307L; SOT23-3
Q3: DMG1013UWQ-7; SOT23-3
R7: 2K; R0603
R8: 10K ntc; R0603
R9: 10K; R0603
R11, R12: 100K; R0603
U$1: MCP1603T-330I/OS; SOT95P280X110-5N
U$2, U$3: COMF_BHC-18650-1P; MR18650_HOLDER
U$5: MCP1252-33X50I/MS; SOP65P490X110-8N

Connections:
3.3V: F3.2; also elsewhere on the board
5V: C27.- (+), D3.A, IC2.1 (VDD1), IC2.2 (VDD2), Q1.1 (G), R9.2; also elsewhere on the board
5V_OUT: Q3.3 (D); also elsewhere on the board
BATT_SENSE: R11.1, R12.2; also elsewhere on the board
BUCK_EN: U$5.7 (!SHDN); also elsewhere on the board
BUCK_PGD: U$5.1 (PGOOD)
CHG: IC2.3 (STAT1); also elsewhere on the board
FULL: IC2.4 (STAT2)
GND: C12.2, C13.2, C19.2, C20.2, C21.1, C27.+ (-), IC2.5 (GND), R7.2, R8.2, R9.1, R12.1, U$1.2 (GND), U$2.P$2 (GND), U$3.P$2 (GND), U$5.4 (GND), U$5.8 (SELECT); also elsewhere on the board
unnamed: F2.1, U$2.P$1 (BAT)
unnamed: C13.1, F3.1, L1.1, U$1.4 (VFB/VOUT)
unnamed: IC2.8 (THERM), R8.1
unnamed: IC2.6 (PROG), R7.1
unnamed: L1.2, U$1.5 (LX)
unnamed: C20.1, Q3.2 (S), U$5.2 (VOUT)
unnamed: C22.1, U$5.6 (C+)
unnamed: C22.2, U$5.5 (C-)
OUT_EN: Q3.1 (G); also elsewhere on the board
VCC: C21.2, D3.C, Q1.2 (S), U$1.1 (VIN), U$1.3 (~SHDN)
V_BATT: C12.1, C19.1, F2.2, IC2.9 (VBAT1), IC2.10 (VBAT2), Q1.3 (D), R11.2, U$3.P$1 (BAT), U$5.3 (VIN)

Notes on the sheet:
X7R Dielectric
3.3V DC-DC Converter
5V Buck Converter
Li-ion Charger

Board: 2 copper layers, 46.0 x 100.0 mm, 110 parts (16 on the bottom side), 65 nets.

Other parts of the board:
U$6: LOLA_LOGO_LAYER
U$7: MRFLOW
U$9: RADIO_LOGO
U$10, U$15: MINUS_LOGO
U$11: ESD_LOGO
U$12: TONNE_LOGO
U$13: AGRO_SMALL_LOGO
U$14: SOUND_ICON
U$16, U$17: PLUS_LOGO
U$18, U$19: BATTERY_LOGO
U$20: CE_LOGO

## Commit log

2020-05-10 Base modules
2020-05-10 StepUp converter plus output-en
2020-05-12 rtc, step-up converter
2020-05-17 Feliratozás van hátra + kondi + buzzer
2020-05-19 Ordered version

Notices in the files:
parts and their libraries:
SparkFun-IC-Microcontroller: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
